## dts/bindings/behaviors/zmk,behavior-pmw3610-setting.yaml
```yaml
description: PMW3610 runtime setting behavior

compatible: "zmk,behavior-pmw3610-setting"

include: one_param.yaml
```
